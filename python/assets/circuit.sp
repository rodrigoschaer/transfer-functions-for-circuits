V1 N001 0 DC 12
R1 N001 N002 1k
R2 N002 N003 2k
C1 N001 N004 1u
C2 N003 N005 2u
L1 N002 N006 1m
E1 N007 0 N001 N002 2
F1 N008 0 V1 0.5
